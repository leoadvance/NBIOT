# IAR project NBIOT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf51822_xxaa NordicSemi nRF51822_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; S110; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\Library\device; ..\User\Main; ..\Library\toolchain\cmsis\include; ..\Library\toolchain; ..\Library\softdevice\common\softdevice_handler; ..\Library\softdevice\s110\headers; ..\Library\softdevice\s110; ..\Library\drivers_nrf\common; ..\Library\drivers_nrf\hal; ..\Library\drivers_nrf\clock; ..\Library\drivers_nrf\delay; ..\Library\drivers_nrf\gpiote; ..\Library\drivers_nrf\uart; ..\Library\drivers_nrf\twi_master; ..\Library\drivers_nrf\adc; ..\Library\drivers_nrf\wdt; ..\Library\libraries\util; ..\Library\libraries\log; ..\Library\libraries\log\src; ..\Library\libraries\scheduler; ..\Library\libraries\timer; ..\Library\libraries\gpiote; ..\Library\libraries\button; ..\Library\libraries\log; ..\Library\libraries\log\src; ..\Library\libraries\twi; ..\Library\libraries\fstorage; ..\Library\libraries\experimental_section_vars; ..\Library\libraries\fds; ..\Library\ble\common; ..\Library\ble\peer_manager; ..\Library\ble\ble_advertising; ..\Library\ble\ble_services\ble_dis; ..\Library\ble\ble_services\ble_bas; ..\User\APP\SysInit; ..\User\APP\Global; ..\User\APP\SW_I2C; ..\User\APP\BLE; ..\User\APP\Button; ..\User\APP\Task; ..\User\APP\Temp_Humi; ..\User\APP\Battery; ..\User\APP\GPIO; ..\User\APP\BLE\BLE_Adv; ..\User\APP\BLE\BLE_Peer; ..\User\APP\BLE\BLE_Evt_Handler; ..\User\APP\BLE\BLE_Services; ..\User\APP\LCD; ..\User\APP\WDT; ..\Library\libraries\trace; ..\Library\drivers_nrf\pstorage; ..\Library\drivers_nrf\pstorage\config; ..\Library\ble\device_manager\config; ..\Library\ble\device_manager; ..\Library\drivers_nrf\hal; ..\Library\libraries\fifo; ..\Library\drivers_nrf\config; ..\User\APP\Debug; ..\Library\ble\ble_services\ble_dfu; ..\User\APP\Communal; ..\User\APP\DFU; ..\Library\libraries\bootloader_dfu; ..\User\APP\Storage; ..\Library\ble\common; ..\User\APP\BLE\BLE_Adv; ..\Library\toolchain; ..\User\APP\Debug; ..\User\APP\tVOC; ..\User\APP\tVOC\SGPC10; ..\User\APP\LCD; ..\User\APP\RTC; ..\User\APP\LCD\LCD_Page; ..\User\APP\EEPROM; ..\User\APP\Historical_Data
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NBIOT.hex
  ILINK.IlinkOutputFile: Duck.out
  ILINK.IlinkIcfFile: ..\USER\Main\iar_s110_nrf51822_xxaa.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP/BLE
    ../User/APP/BLE/: nRF51_BLE.c nRF51_BLE.h nRF51_BLE_Init.c nRF51_BLE_Init.h
  group APP/BLE/BLE_Adv
    ../User/APP/BLE/BLE_Adv/: nRF51_BLE_Adv.c nRF51_BLE_Adv.h nRF51_BLE_Adv_Port.c nRF51_BLE_Adv_Port.h
  group APP/BLE/BLE_Evt_Handler
    ../User/APP/BLE/BLE_Evt_Handler/: nRF51_BLE_Evt_Handler.c nRF51_BLE_Evt_Handler.h
  group APP/BLE/BLE_Peer
    ../User/APP/BLE/BLE_Peer/: nRF51_BLE_Peer.c nRF51_BLE_Peer.h
  group APP/BLE/BLE_Services
    ../User/APP/BLE/BLE_Services/: nRF51_BLE_DevInfo_Service.c nRF51_BLE_DevInfo_Service.h nRF51_BLE_Private_Service.c nRF51_BLE_Private_Service.h nRF51_BLE_Test_Ack.c nRF51_BLE_Test_Ack.h
  group APP/Button
    ../User/APP/Button/: Button.c Button.h Button_Double.c Button_Double.h Button_Long.c Button_Long.h Button_Port.c Button_Port.h Button_Single.c Button_Single.h
  group APP/Communal
    ../User/APP/Communal/: Communal_Flash.c Communal_Flash.h Communal_IIC.c Communal_IIC.h Communal_IIC_2.c Communal_IIC_2.h Communal_Timer.c Communal_Timer.h
  group APP/Debug
    ../User/APP/Debug/: Debug.c Debug.h Debug_Port.c Debug_Port.h
  group APP/DFU
    ../User/APP/DFU/: nRF51_DFU.c nRF51_DFU.h
  group APP/EEPROM
    ../User/APP/EEPROM/: EEPROM.c EEPROM.h EEPROM_Port.c EEPROM_Port.h
  group APP/Global
    ../User/APP/Global/: Global.c Global.h Global_Cfg.h Global_Typedef.h Struct.h
  group APP/GPIO
    ../User/APP/GPIO/: GPIO.c GPIO.h GPIO_Port.c GPIO_Port.h
  group APP/Historical_Data
    ../User/APP/Historical_Data/: Historical_Data.c Historical_Data.h
  group APP/LCD
    ../User/APP/LCD/: LCD.c LCD.h LCD_Port.c LCD_Port.h OLED.c OLED.h
  group APP/LCD/LCD_Page
    ../User/APP/LCD/LCD_Page/: LCD_Page_Baseline.c LCD_Page_Baseline.h LCD_Page_Sensor.c LCD_Page_Sensor.h LCD_Page_Time.c LCD_Page_Time.h
  group APP/RTC
    ../User/APP/RTC/: RTC.c RTC.h RTC_DS1307.c RTC_DS1307.h
  group APP/Storage
    ../User/APP/Storage/: nRF51_Storage.c nRF51_Storage.h
  group APP/SW_I2C
    ../User/APP/SW_I2C/: SW_I2C.c SW_I2C.h
  group APP/Sysinit
    ../User/APP/SysInit/: SysInit.c SysInit.h
  group APP/Task
    ../User/APP/Task/: Task.c Task.h
  group APP/Temp_Humi
    ../User/APP/Temp_Humi/: Temp_Humi.c Temp_Humi.h Temp_Humi_Port.c Temp_Humi_Port.h Temp_Humi_SHT30.c Temp_Humi_SHT30.h
  group APP/tVOC
    ../User/APP/tVOC/: tVOC.c tVOC.h tVOC_SGPC.c tVOC_SGPC.h
  group APP/tVOC/SGPC10
    ../User/APP/tVOC/SGPC10/: sensirion_common.c sensirion_common.h sgpc1x.c sgpc1x.h sgpc1x_featureset.c sgpc1x_featureset.h
  group APP/WDT
    ../User/APP/WDT/: WDT.c WDT.h
  group main
    ../User/Main/: iar_startup_nrf51.s main.c
  group nRF_BLE
    ../Library/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../Library/ble/ble_advertising/: ble_advertising.c
    ../Library/ble/ble_services/ble_bas/: ble_bas.c
    ../Library/ble/ble_services/ble_dfu/: ble_dfu.c
    ../Library/ble/ble_services/ble_dis/: ble_dis.c
    ../Library/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../Library/drivers_nrf/uart/: app_uart_fifo.c
    ../Library/drivers_nrf/hal/: nrf_adc.c nrf_delay.c
    ../Library/drivers_nrf/clock/: nrf_drv_clock.c
    ../Library/drivers_nrf/common/: nrf_drv_common.c
    ../Library/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../Library/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../Library/drivers_nrf/pstorage/: pstorage.c
  group nRF_Library
    ../Library/libraries/button/: app_button.c
    ../Library/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../Library/libraries/fifo/: app_fifo.c
    ../Library/libraries/scheduler/: app_scheduler.c
    ../Library/libraries/timer/: app_timer.c app_timer_appsh.c
    ../Library/libraries/trace/: app_trace.c
    ../Library/libraries/bootloader_dfu/: bootloader_util.c dfu_app_handler.c
    ../Library/libraries/uart/: retarget.c
  group nRF_SoftDevices
    ../Library/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group nRF_Toolchain
    ../Library/toolchain/: system_nrf51.c
